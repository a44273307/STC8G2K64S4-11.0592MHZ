# Keil uVision project 1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT83C5135 Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0x3FFF) CLOCK(24000000) MODP2
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 1.c delay.c
